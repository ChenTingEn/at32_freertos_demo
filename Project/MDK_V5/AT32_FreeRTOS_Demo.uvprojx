# Keil uVision project AT32_FreeRTOS_Demo.uvprojx, settings and files
target FreeRTOS_Demo_403A (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: -AT32F421C8T7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.4
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: AT32_FreeRTOS_Demo
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1_0
  c include: ..\inc;..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\..\Project\AT32_Board;..\..\..\Middlewares\FreeRTOS\Source\include;..\..\..\Libraries\CMSIS\CM4\DeviceSupport;..\..\..\Middlewares\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Drivers/BSP
    ../../Bsp/: at32_board.c
  group Drivers/CMSIS
    ../../Libraries/CMSIS/CM4/DeviceSupport/: system_at32f4xx.c at32f4xx.h
    ../../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f421c8t7.s
  group User
    ../../User/: at32f4xx_it.c main.c
  group Drivers/AT32Periph
    ../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_acc.c at32f4xx_adc.c at32f4xx_bkp.c at32f4xx_can.c at32f4xx_comp.c at32f4xx_crc.c at32f4xx_dac.c at32f4xx_dbgmcu.c at32f4xx_dma.c at32f4xx_ertc.c at32f4xx_eth.c at32f4xx_exti.c at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_gpio_ex.c at32f4xx_i2c.c at32f4xx_iwdg.c at32f4xx_pwr.c at32f4xx_rcc.c at32f4xx_rtc.c at32f4xx_sdio.c at32f4xx_spi.c at32f4xx_syscfg.c at32f4xx_tim.c at32f4xx_usart.c at32f4xx_wwdg.c at32f4xx_xmc.c misc.c
  group Source/FreeRTOS
    ../../Middlewares/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../Middlewares/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../User/: FreeRTOSConfig.h
    ../../Middlewares/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../Middlewares/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port_nofpu.c
  group Hardware
    ../../Hardware/uart_manager/: uart_manager.c
    ../../Hardware/usart/: usart.c
target FreeRTOS_Demo_407 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: -AT32F421C8T7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.4
  cpu: as above
  output: AT32_FreeRTOS_Demo
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F407VGT7,USE_STDPERIPH_DRIVER,AT_START_F407_V1_0
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
target FreeRTOS_Demo_403 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.4
  cpu: as above
  output: AT32_FreeRTOS_Demo
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F403Zx_XL,USE_STDPERIPH_DRIVER,AT_START_F403_V1_2
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
target FreeRTOS_Demo_413 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.4
  cpu: as above
  output: AT32_FreeRTOS_Demo
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F413Rx_HD,USE_STDPERIPH_DRIVER,AT_START_F413_V1_0
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
target FreeRTOS_Demo_415 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: -AT32F421C8T7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.4
  cpu: as above
  output: AT32_FreeRTOS_Demo
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F415C8T7,USE_STDPERIPH_DRIVER,AT_START_F415_V1_0
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
target FreeRTOS_Demo_421 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F421C8T7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.4
  cpu: as above
  output: AT32_FreeRTOS_Demo
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F421C8T7,USE_STDPERIPH_DRIVER,AT_START_F421_V1_0
  c include: ..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\Middlewares\FreeRTOS\Source\include;..\..\Libraries\CMSIS\CM4\DeviceSupport;..\..\Middlewares\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\Middlewares\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\Bsp;..\..\User;..\..\Hardware\uart_manager;..\..\Hardware\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
